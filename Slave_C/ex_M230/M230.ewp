# IAR project M230.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../components/utils; ../../components/common; ../../components/basicrf; ../../components/module; ../../components/targets/mcu-kit1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0 Evaluation\8051\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group application
    ../../components/module/: M230.c
    ./: Program.c Slave_C.c
  group basic rf
    ../../components/basicrf/: basic_rf.c basic_rf_security.c
  group common
    ../../components/common/: hal_cc8051.h hal_clock.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c ioCC2530.h
  group targets
    ../../components/targets/zigbee-mcu1/: hal_board.c hal_buzzer.c hal_led.c
  group utilities
    ../../components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
