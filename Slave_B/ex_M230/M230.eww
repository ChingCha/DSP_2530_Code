<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Master_A\ex_M230\M230.ewp</path>
  </project>
  <batchBuild/>
</workspace>


